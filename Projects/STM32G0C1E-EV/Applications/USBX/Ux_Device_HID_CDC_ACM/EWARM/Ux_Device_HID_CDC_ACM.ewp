# IAR project Ux_Device_HID_CDC_ACM.ewp, settings and files
configuration Ux_Device_HID_CDC_ACM (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0C1VE ST STM32G0C1VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 5
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _SNK; USBPDCORE_LIB_NO_PD; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; USE_HAL_DRIVER; STM32G0C1xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../AZURE_RTOS/App; ../USBX/App; ../USBX/Target; ../USBPD/App; ../USBPD/Target; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/usbx/common/core/inc/; ../../../../../../Middlewares/ST/usbx/ports/generic/inc/; ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc/; ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/; ../../../../../../Middlewares/ST/threadx/common/inc/; ../../../../../../Middlewares/ST/threadx/ports/cortex_m0/iar/inc/; ../../../../../../Drivers/BSP/STM32G0C1E-EV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ux_Device_HID_CDC_ACM.hex
  ILINK.IlinkOutputFile: Ux_Device_HID_CDC_ACM.out
  ILINK.IlinkIcfFile: stm32g0c1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0c1xx.s
  group Application/User/Core
    ../Core/Src/: main.c tx_initialize_low_level.S app_threadx.c stm32g0xx_it.c stm32g0xx_hal_msp.c stm32g0xx_hal_timebase_tim.c
  group Application/User/USBPD/Target
    ../USBPD/Target/: usbpd_dpm_user.c usbpd_pwr_user.c
  group Application/User/USBPD/App
    ../USBPD/App/: usbpd.c usbpd_pwr_if.c usbpd_dpm_core.c usbpd_usb_if.c
  group Application/User/USBX/App
    ../USBX/App/: ux_device_descriptors.c ux_device_cdc_acm.c ux_device_mouse.c app_usbx_device.c
  group Application/User/AZURE_RTOS/App
    ../AZURE_RTOS/App/: app_azure_rtos.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c stm32g0c1e_eval_pwr.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_lptim.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_crs.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_ll_usb.c stm32g0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Middlewares/USBPD
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM0PLUS_wc32.a
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
  group Middlewares/USBX/USB/USBX/UX Device CoreStack
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_tasks_run.c ux_device_stack_transfer_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c
  group Middlewares/USBX/USB/USBX/UX Device Class HID
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_hid_read.c ux_device_class_hid_receiver_event_free.c ux_device_class_hid_receiver_event_get.c ux_device_class_hid_receiver_initialize.c ux_device_class_hid_receiver_thread.c ux_device_class_hid_receiver_uninitialize.c ux_device_class_hid_tasks_run.c ux_device_class_hid_activate.c ux_device_class_hid_control_request.c ux_device_class_hid_deactivate.c ux_device_class_hid_descriptor_send.c ux_device_class_hid_entry.c ux_device_class_hid_event_get.c ux_device_class_hid_event_set.c ux_device_class_hid_initialize.c ux_device_class_hid_interrupt_thread.c ux_device_class_hid_report_get.c ux_device_class_hid_report_set.c ux_device_class_hid_uninitialize.c
  group Middlewares/USBX/USB/USBX/CoreSystem
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_tasks_run.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/USBX/USB/USBX/UX Device Controllers
    ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_transfer_run.c ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/USB/USBX/UX Device Class CDC ACM
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_read_run.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_write_run.c ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_write_with_callback.c
  group Middlewares/ThreadX/RTOS/ThreadX/Core
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m0/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s tx_iar.c
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
